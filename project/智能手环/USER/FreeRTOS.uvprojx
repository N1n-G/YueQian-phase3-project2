# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\FREERTOS\include;..\FREERTOS\port;..\HARDWARE\LCD;.\;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\HARDWARE\DHT;..\HARDWARE\TOUCH;..\MAX30102;..\I2C;..\ALGORITHM;..\HARDWARE\BLE;..\HARDWARE\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c menu.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: tft.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DHT/: dht11.c
    ../HARDWARE/TOUCH/: touch.c
    ../MAX30102/: max30102.c
    ../I2C/: i2c.c
    ../ALGORITHM/: algorithm.c
    ../HARDWARE/BLE/: blue_tooth.c
    ../HARDWARE/MPU6050/: mpu6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_pwr.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_spi.c
  group FreeRTOS_CORE
    ../FREERTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FREERTOS/heap/: heap_4.c
    ../FREERTOS/port/: port.c
  group PIC
    ../HARDWARE/LCD/: pic_camera.c pic_date.c pic_faceid.c pic_pulse.c pic_logo.c pic_rfid.c pic_touchid.c pic_temp_humi.c pic_storage.c pic_battery.c pic_ble.c pic.h pic_light.c pic_time.c pic_temperature.c pic_humidity.c pic_step.c pic_settings.c pic_games.c pic_in_the_pulse.c pic_heart_rate.c pic_blood_oxygen.c pic_penguin.c pic_show_date_time.c pic_weather.c pic_success.c pic_set_time.c pic_date1.c pic_remain_w.c pic_walk_count.c pic_sedentary.c pic_sedentary_remind.c
